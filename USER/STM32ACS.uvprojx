# Keil uVision project STM32ACS.uvprojx, settings and files
target Target 1 (5060020::V5.06 (build 20)::ARMCC)
  device: STM32F103RC STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.1.0
  cpu: IROM(0x08000000,0x40000) IRAM(0x20000000,0xC000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: STM32ACS +hex
  c flags: Optim=1 OneElfS=1 wLevel=2
  c define: STM32F10X_HD
  c include: ..\SYSTEM\sys;..\SYSTEM\delay;..\SYSTEM\usart;..\HARDWARE\DOR;..\HARDWARE\EXTI;..\HARDWARE\FLASH;..\HARDWARE\KEY;..\HARDWARE\LED;..\HARDWARE\SPI;..\HARDWARE\VOICE;..\SOFTWARE\AUTH;..\SOFTWARE\SEC;..\SOFTWARE\TCPIP;..\SOFTWARE\USERKEY;..\SOFTWARE\WG
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0xc000
  group USER
    ./: test.c
  group STSTEM
    ../SYSTEM/delay/: delay.c
    ../SYSTEM/sys/: sys.c
    ../SYSTEM/startup_stm32f10x/: startup_stm32f10x_hd.s
    ../SYSTEM/usart/: usart.c
  group SOFTWARE
    ../SOFTWARE/AUTH/: auth.c
    ../SOFTWARE/SEC/: sec.c
    ../SOFTWARE/TCPIP/: tcpip.c
    ../SOFTWARE/USERKEY/: userkey.c
    ../SOFTWARE/WG/: wg.c
  group HARDWARE
    ../HARDWARE/DOR/: dor.c
    ../HARDWARE/EXTI/: exti.c
    ../HARDWARE/FLASH/: flash.c
    ../HARDWARE/KEY/: key.c
    ../HARDWARE/LED/: led.c
    ../HARDWARE/SPI/: spi.c
    ../HARDWARE/VOICE/: voice.c
