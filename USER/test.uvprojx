# Keil uVision project test.uvprojx, settings and files
target Target 1 (5060020::V5.06 (build 20)::ARMCC)
  device: STM32F103RC STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.1.0
  cpu: IROM(0x08000000,0x40000) IRAM(0x20000000,0xC000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: test +hex
  c flags: Optim=1 OneElfS=1
  c define: STM32F10X_HD
  c include: ..\SYSTEM\delay;..\SYSTEM\sys;..\SYSTEM\usart;..\HARDWARE\LED;..\HARDWARE\KEY;..\HARDWARE\EXTI;..\HARDWARE\DOR;..\SOFTWARE\AUTH;..\SOFTWARE\WG;..\SOFTWARE\USERKEY;..\SOFTWARE\SEC;..\HARDWARE\FLASH;..\HARDWARE\SPI
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0xc000
  group Source Group 1
    ./: startup_stm32f10x_hd.s
  group USER
    ./: test.c
  group SYSTEM
    ../SYSTEM/delay/: delay.c
    ../SYSTEM/sys/: sys.c
    ../SYSTEM/usart/: usart.c
  group HARDWARE
    ../HARDWARE/LED/: led.c
    ../HARDWARE/KEY/: key.c
    ../HARDWARE/EXTI/: exti.c
    ../HARDWARE/DOR/: dor.c
    ../HARDWARE/FLASH/: flash.c
    ../HARDWARE/SPI/: spi.c
  group README
    ../: README.TXT
  group SOFTWARE
    ../SOFTWARE/AUTH/: auth.c
    ../SOFTWARE/USERKEY/: userkey.c
    ../SOFTWARE/WG/: wg.c
    ../SOFTWARE/SEC/: sec.c
